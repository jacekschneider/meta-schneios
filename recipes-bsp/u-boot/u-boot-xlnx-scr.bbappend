FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-xlnx-scr:"

SRC_URI += " file://boot.cmd.generic.schneios"