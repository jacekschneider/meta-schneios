FILESEXTRAPATHS:prepend := "${THISDIR}/embeddedsw:"

SRC_URI += " file://0001-te-install-general-hooks-zynq.patch \
             file://0001-te-install-general-hooks-zynqmp.patch \
             "
